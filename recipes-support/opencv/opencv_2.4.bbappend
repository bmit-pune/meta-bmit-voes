EXTRA_OECMAKE_prepend = "\
    -DWITH_GSTREAMER=ON \
    "


